Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_UE125WJ_INT-EN.ifc
Time: 2025-08-05T18:28:19+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2019967_1 | SINK
OutPort_2019967_2 | SOURCE

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_INT-EN:UE125WJ, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_INT-EN:UE125WJ:2019967
In: F00
Type - Material: Color RGB 055-055-055, Color RGB 168-128-048, Color RGB 235-235-235
Type - Other - Category: Pipe Accessories; B1: 163 mm; B2: 165.56 mm; Connection Diameter: 31.75 mm; d: 31.75 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_INT-EN; h: 160 mm; h1: 50 mm; Hh: 210 mm; OD: 42.4 mm; Radius: 15.875 mm; Sweep Radius: 25 mm; T Diameter: 49 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - b: 138 mm; D1: 84 mm; Hv: 224 mm; L: 128 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Brass 1 1/4" - Magnet; Article Type: UE125WJ; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Brass 1 1/4" - Magnet; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811041482; Manufacturer: Spirotech; Manufacturer Art. No.: UE125WJ; Manufacturer URL: https://www.spirotech.com/8717811041482; MEPcontent Class: SEPARATOR_DIRT; Model: UE125WJ; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: UE125WJ; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Dark Yellow: Color RGB 168-128-048
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.001 m3/s; Pressure Stage: 0; Volume: 0.0008 m3; Weight: 3.6 kg
Type - Mechanical - Flow - Pressure Drop: 2200 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UE125WJ; sets with these values: 2
Other - Bottom Clearance Safe: 110 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MBL_INT-EN: UE125WJ; Top Clearance Safe: 50 mm; Type: UE125WJ; Type Id: 2019948
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.114711 m2; Maximum Size: 31.75 mm; Minimum Size: 31.75 mm; Volume: 0.00173977 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow 1: 0 m3/s; Flow 2: 0 m3/s; System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 110 mm; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
